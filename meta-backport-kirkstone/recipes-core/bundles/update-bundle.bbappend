RAUC_SLOT_rootfs[file] = "core-image-minimal-${MACHINE}-p5.img"
RAUC_SLOT_firmware[file] = "core-image-minimal-${MACHINE}-p2.img"
